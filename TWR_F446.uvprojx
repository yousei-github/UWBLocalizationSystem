# Keil uVision project TWR_F446.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TWR_F446
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARM_MATH_CM4
  c include: .\RTE\_Target_1\OS\uCOS-III\APP;.\RTE\_Target_1\OS\uCOS-III\BSP;.\RTE\_Target_1\OS\uCOS-III\Software\uC-CPU;.\RTE\_Target_1\OS\uCOS-III\Software\uC-LIB;.\RTE\_Target_1\OS\uCOS-III\Software\uCOS-III\Source;.\RTE\_Target_1\OS\uCOS-III\Software\uC-CPU\ARM-Cortex-M4\RealView;.\RTE\_Target_1\OS\uCOS-III\Software\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F446RETx/STCubeGenerated/Src/: main.c stm32f4xx_it.c
    ./RTE/Device/STM32F446RETx/STCubeGenerated/Inc/: stm32f4xx_it.h
  group OS
    ./RTE/_Target_1/OS/uCOS-III/APP/: app.c app_cfg.h cpu_cfg.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h UCOS_includes.h
    ./RTE/_Target_1/OS/uCOS-III/BSP/: bsp.c bsp.h bsp_int.c bsp_periph.c
    ./RTE/_Target_1/OS/uCOS-III/Software/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ./RTE/_Target_1/OS/uCOS-III/Software/uC-CPU/ARM-Cortex-M4/RealView/: cpu.h cpu_a.asm cpu_c.c
    ./RTE/_Target_1/OS/uCOS-III/Software/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ./RTE/_Target_1/OS/uCOS-III/Software/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
    ./RTE/_Target_1/OS/uCOS-III/Software/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
    ./RTE/_Target_1/OS/uCOS-III/Software/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group DWM1000
    ./RTE/_Target_1/: DWM1000.c
    ./RTE/_Target_1/decadriver/: deca_device.c deca_params_init.c
    ./RTE/_Target_1/platform/: deca_mutex.c deca_range_tables.c deca_sleep.c deca_spi.c DWM1000_peripheral.c
  group Algoraithm
    ./RTE/_Target_1/: Position_algorithm.c
  group Led
    ./RTE/_Target_1/: led.c
  group Sensors
    ./RTE/_Target_1/: SPL06_001.c
software components: CMSIS:CORE 5.1.2, CMSIS:DSP 1.5.2, Device:STM32Cube HAL:ADC 1.7.4, Device:STM32Cube HAL:Common 1.7.4, Device:STM32Cube HAL:Cortex 1.7.4, Device:STM32Cube HAL:DMA 1.7.4, Device:STM32Cube HAL:GPIO 1.7.4, Device:STM32Cube HAL:HCD 1.7.4, Device:STM32Cube HAL:I2C 1.7.4, Device:STM32Cube HAL:PWR 1.7.4, Device:STM32Cube HAL:RCC 1.7.4, Device:STM32Cube HAL:SPI 1.7.4, Device:STM32Cube HAL:TIM 1.7.4, Device:STM32Cube HAL:UART 1.7.4, Device:Startup 2.6.2
